# Keil uVision project sensor_beacon.uvprojx, settings and files
target sensor_beacon (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.28.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: sensor_beacon +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: NRF52,SYS_CFG_USE_TWI0, SYS_CFG_SERIAL_0_IRQ_PRIORITY= 3, PCA20014, TEMPERATURE_AND_PRESSURE_BEACON
  c misc: --c99
  c include: ..\..\..\inc;..\..\..\external\framework\cunit;..\..\..\external\comp_generic\hal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\scatter.sct
  group app
    ../../../src/: sensor_beacon.c
  group libs
    ../../../src/: drv_bme280.c drv_mcp9808.c hal_clock.c hal_radio.c hal_timer.c
    ../../../external/comp_generic/hal/src/: hal_serial.c hal_twi.c
software components: CMSIS:CORE 3.20.0, Device:Startup 8.28.0
