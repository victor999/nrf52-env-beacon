# Keil uVision project sensor_beacon.uvprojx, settings and files
target sensor_beacon (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sensor_beacon +hex
  c flags: Optim=4 v6Lang=3 v6LangP=3 wLevel=2
  c define: SYS_CFG_USE_TWI0, SYS_CFG_SERIAL_0_IRQ_PRIORITY= 3, PCA20014, TEMPERATURE_AND_BATTERY_BEACON, NRF52_PAN_74
  c misc: --c99
  c include: ..\..\..\inc;..\..\..\external\framework\cunit;..\..\..\external\comp_generic\hal\inc;..\..\..\external\comp_generic\util;..\..\..\external\drivers;..\..\..\external\hal
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\scatter.sct
  group app
    ../../../src/: sensor_beacon.c
    ../../../inc/: defines.h
  group libs
    ../../../src/: hal_clock.c hal_radio.c hal_timer.c drv_bme280.c drv_mcp9808.c
    ../../../external/comp_generic/hal/src/: hal_serial.c hal_twi.c
  group drivers
    ../../../external/drivers/: nrf_drv_common.c nrf_drv_saadc.c
  group hal
    ../../../external/hal/: nrf_saadc.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.17.0
